# Keil uVision project template.uvproj, settings and files
target template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template
  c flags: Optim=1
  c include: .\include;.\src\ccdebug\inlcude;.\src\libstm32\cmsis;.\src\libstm32\inc;.\src\ucosii\src;.\src\ucosii\port;.\src\task;.\src\HARDWARE\SRAM;.\src\HARDWARE\TIMER;.\src\HARDWARE\ENC28J60;.\src\HARDWARE\USART;.\src\HARDWARE\VS10XX;.\src\mem;.\src\collect\include;.\src\SYSTEM;.\src\SYSTEM\sys;.\src\SYSTEM\delay;.\src\LWIP;.\src\LWIP\lwip-1.4.1\src\include;.\src\LWIP\lwip-1.4.1\src\include\ipv4;.\src\LWIP\lwip-1.4.1\src\include\netif;.\src\LWIP\lwip_app\lwip_comm;.\src\LWIP\lwip_app\web_server_demo
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group libstm32
    ./src/libstm32/src/: stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ./src/libstm32/cmsis/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group init
    ./src/init/: main.c stm32f10x_it.c
  group HARDWARE
    ./src/HARDWARE/SRAM/: sram.c
    ./src/HARDWARE/ENC28J60/: enc28j60.c
    ./src/HARDWARE/TIMER/: timerx.c
    ./src/HARDWARE/USART/: debug_usart.c
    ./src/HARDWARE/VS10XX/: vs10xx.c
  group ucosii
    ./src/ucosii/src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ./src/ucosii/port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group TASK
    ./src/task/: task_startup.c task_tcpserver.c task_udpserver.c task_udpclient.c
  group MEM
    ./src/mem/: lib_mem.c
  group Collect
    ./src/collect/: array.c common.c deque.c hashset.c hashtable.c list.c queue.c slist.c stack.c treeset.c treetable.c
  group SYSTEM
    ./src/SYSTEM/sys/: mysys.c
    ./src/SYSTEM/delay/: delay.c
  group LWIP_APP
    ./src/LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ./src/LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group LWIP_NETIF
    ./src/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ./src/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./src/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_ARCH
    ./src/LWIP/arch/: sys_arch.c
  group LWIP_API
    ./src/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group CCDEBUG
    ./src/ccdebug/: ccdebug_port.c
